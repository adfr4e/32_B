# Keil uVision project HBM32.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: HBM32G003 Honor
  pack: Honor.HBM32_DFP.2.0.2
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HBM32 +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CMSIS;..\Drivers\Inc;..\Startup;..\User\Inc;..\Hardware\Inc;..\Os\Inc;..\App\Inc;..\Common;..\Mid\Inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Startup
    ../Startup/: startup_HBM32G003.s
  group Drivers
    ../Drivers/Src/: HBM32G003_adc.c HBM32G003_exti.c HBM32G003_flash.c HBM32G003_gpio.c HBM32G003_iic.c HBM32G003_iwdt.c HBM32G003_port.c HBM32G003_power.c HBM32G003_pwmbase.c HBM32G003_pwmplus.c HBM32G003_spi.c HBM32G003_timerplus.c HBM32G003_uart.c
  group Os
    ../Os/Src/: OS_System.c
  group Hardware
    ../Hardware/Src/: Led.c delay.c Key.c Bk4819.c Spi.c Cpu.c
  group User
    ../User/Src/: main.c system_HBM32G003.c
software components: CMSIS:CORE 5.0.1
